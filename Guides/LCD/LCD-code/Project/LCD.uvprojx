# Keil uVision project LCD.uvprojx, settings and files
target LCD (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LCD +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\BaseDrive;..\Libraries\CORE;..\Libraries\STM32F10x_FWLib\inc;..\Libraries\STM32F10x_FWLib\src;..\USER;..\ExternalDrive;..\ExternalDrive\LCD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Lib
    ../Libraries/CORE/: core_cm3.c
    ../Libraries/STM32F10x_FWLib/src/: misc.c stm32f10x_bkp.c stm32f10x_adc.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c system_stm32f10x.c
  group Cmsis
    ../Libraries/CORE/: startup_stm32f10x_hd.s
  group BaseDrive
    ../BaseDrive/: delay.c
  group ExternalDrive
    ../ExternalDrive/: USART1.c LED.c
    ../ExternalDrive/lcd/: LCD.c
  group User
    ../USER/: main.c
    ../User/: stm32f10x_it.c
  group Doc
    ../Doc/: ReadMe.txt
